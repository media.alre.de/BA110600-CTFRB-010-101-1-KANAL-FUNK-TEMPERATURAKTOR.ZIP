Properties of the parts of a building model (IFC4)

# File
Description: Funk-Kühlungsaktor, Aufputz, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BA110600, Funk-Kühlungsaktor, Aufputz
In: Raum
Description: 1-Kanal Funk-Temperaturaktor nur für Kühlen, der in Verbindung mit alre-Funk-Raumtemperatursensoren eine Einzelraum-Temperaturregelung verwirklicht. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen.; Classification: EC000436 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BA110600; ModelLabel: CTFRB-010.101; GlobalTradeItemNumber: 4050528015112; ProductURL: https://alre.de/produkt_BA110600
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.081
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Stromversorgung: 230 V AC; Anzahl der Relais: 1; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; Funkfrequenz: 868; RAL-Nummer (ähnlich): 9010; Ausführung der Oberfläche: matt; Geeignet für Schutzart (IP): IP30; ETIM-Klasse: EC000436; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BA110600.pdf
